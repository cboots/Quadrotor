# Repository cboots/Quadrotor

File README.md:

Quadrotor
======

This project contains all the schematics, code, documentation and CAD files for my quadrotor designs.

## KiCad design Avionics/Flight Computer/Flight Computer.kicad_pcb

File Avionics/Readme.txt:

This folder holds all of the electronics designs for the quads

Parts:
C91, C94: 1u; C_0402; Voltage 16V; Tolerance 20%
C92, C93: GRM155R61C474KE01D; C_0402; Voltage 16V; Tolerance 20%
D3: CLX6D-FKB-CMPQSGKBB7A363; LED_PLCC6_3.4x3.4mm; Manufacturer Part Number CLX6D-FKB-CMPQSGKBB7A363
D4, D8: MF-LED-0603-GREEN; LED_0603
MK1, MK2: Mounting_Hole; MountingHole_2.5mm
R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34: 1k; R_0402; Tolerance 1%; Voltage 16V
R39, R45, R49: 10k; R_0402; Tolerance 1%; Voltage 16V
R40, R41: DNP; R_0402; Tolerance 1%; Voltage 16V
U6: LP5521YQ/NOPB; QFN-24-1EP_4x5mm_Pitch0.5mm
U10, U11: Logo; NaviLOGO

Connections:
+3V3: C91.1, R27.1, R28.1, R39.1, R45.1, U6.3 (VDD); also elsewhere on the board
/2.4 GHz Radio/~RESET: R32.2, R33.2, R34.2; also elsewhere on the board
/2.4_RESET_900: R33.1; also elsewhere on the board
/2.4_RESET_CPU: R34.1; also elsewhere on the board
/2.4_RESET_EXT: R32.1
/900MHz Radio/~RESET: R29.2, R30.2, R31.2; also elsewhere on the board
/900_RESET_2.4: R30.1; also elsewhere on the board
/900_RESET_CPU: R31.1; also elsewhere on the board
/900_RESET_EXT: R29.1
/CPU-SCK: R28.2, R40.2, U6.15 (SCL); also elsewhere on the board
/CPU-SDA: R27.2, R41.2, U6.13 (SDA); also elsewhere on the board
/CPU_RESET_2.4: R25.1; also elsewhere on the board
/CPU_RESET_900: R26.1; also elsewhere on the board
/CPU_RESET_EXT: R24.1
/GNC_Processor/IMU-SPI-CLK: R40.1; also elsewhere on the board
/GNC_Processor/IMU-SPI-MOSI: R41.1; also elsewhere on the board
/GNC_Processor/~RESET: R24.2, R25.2, R26.2; also elsewhere on the board
GND: C91.2, C94.2, D3.1 (RK), D3.2 (GK), D3.3 (BK), D4.1 (K), D8.1 (K), U6.4 (GND), U6.5 (CLK_32K), U6.7 (TRIG), U6.20, U6.21, U6.~ (ADDR_SEL0); also elsewhere on the board
unnamed: C92.1, U6.2 (CFLY1P)
unnamed: C92.2, U6.24 (CFLY1N)
unnamed: C93.1, U6.1 (CFLY2P)
unnamed: C93.2, U6.23 (CFLY2N)
unnamed: C94.1, U6.22 (VOUT)
unnamed: D3.4 (BA), U6.17 (R)
unnamed: D3.5 (GA), U6.18 (G)
unnamed: D3.6 (RA), U6.19 (B)
unnamed: D4.2 (A), R45.2
unnamed: D8.2 (A), R49.2
unnamed: R39.2, U6.14 (EN)
VUSB: R49.1; also elsewhere on the board

Notes on the sheet:
100k-PU

Parts:
C57, C69, C72, C73, C74, C75, C76, C77, C78, C79, C80, C81, C82, C83, C84, C90: 0.1u; C_0402; Voltage 16V; Tolerance 20%
C59: 0.01u; C_0402; Voltage 16V; Tolerance 20%
C60, C62, C63, C64, C65: GRM1555C1H120GA01D; C_0402; Voltage 16V; Tolerance 20%
C61, C68, C87: 1u; C_0402; Voltage 16V; Tolerance 20%
C85, C86: CC0603KRX5R7BB475; C_0603; Voltage 16V; Tolerance 20%
L19, L20: MMZ1005Y471CTD25; L_0402
L21: LQM21FN100M70L; L_0805
R20: 5.6k; R_0402; Tolerance 1%; Voltage 16V
R21: 18k; R_0402; Tolerance 1%; Voltage 16V
R22: 15k; R_0402; Tolerance 1%; Voltage 16V
R23: ERJ-2GEJ2R2X; R_0402; Tolerance 1%; Voltage 16V
R37: 100k; R_0402; Tolerance 1%; Voltage 50V
R38: 10k; R_0402; Tolerance 1%; Voltage 50V
TP1: TST; Measurement_Point_Round-SMD-Pad_Very_Small
TP2: ERASE; Measurement_Point_Round-SMD-Pad_Very_Small
TP3: JTAGSEL; Measurement_Point_Round-SMD-Pad_Very_Small
U12: ATSAME70Q21A-AN; LQFP-144_20x20mm_Pitch0.5mm
Y1: 9HT11-32.768KDZB-T; Crystal_SMD_2012-2pin_2.0x1.2mm
Y2: 7V-16.000MAHJ-T; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
+3V3: C78.1, C79.1, C80.1, C81.1, C82.1, C83.1, C84.2, C85.2, C87.1, R23.1, U12.5 (VDDIN), U12.9 (VREFP), U12.30 (VDDIO), U12.43 (VDDIO), U12.72 (VDDIO), U12.80 (VDDIO), U12.96 (VDDIO), U12.134 (VDDUTMII); also elsewhere on the board
+BATT: R37.2; also elsewhere on the board
/2.4G-Rx: U12.66 (PA10/PIODC4); also elsewhere on the board
/2.4G-Tx: U12.75 (PA9/PIODC3); also elsewhere on the board
/2.4_RESET_CPU: U12.84 (PD14); also elsewhere on the board
/900M-Rx: U12.67 (PD19); also elsewhere on the board
/900M-Tx: U12.69 (PD18); also elsewhere on the board
/900_RESET_CPU: U12.88 (PD13); also elsewhere on the board
/CPU-SCK: U12.77 (PA4/PIODC1); also elsewhere on the board
/CPU-SDA: U12.91 (PA3/PIODC0); also elsewhere on the board
/Connectors/PA0: U12.102 (PA0/WKUP0)
/Connectors/PA1: U12.99 (PA1/WKUP1)
/Connectors/PA11: U12.64 (PA11/PIODC5)
/Connectors/PA12: U12.68 (PA12/PIODC6)
/Connectors/PA13: U12.42 (PA13/PIODC7)
/Connectors/PA14: U12.51 (PA14/PIODCEN1)
/Connectors/PA15: U12.49 (PA15)
/Connectors/PA16: U12.45 (PA16)
/Connectors/PA17: U12.25 (PA17/AFE0_AD6)
/Connectors/PA18: U12.24 (PA18/AFE0_AD7)
/Connectors/PA19: U12.23 (PA19/AFE0_AD8)
/Connectors/PA20: U12.22 (PA20/AFE0_AD9)
/Connectors/PA21: U12.32 (PA21/AFE0_AD1)
/Connectors/PA22: U12.37 (PA22/PIODCCLK)
/Connectors/PA23: U12.46 (PA23)
/Connectors/PA24: U12.56 (PA24)
/Connectors/PA25: U12.59 (PA25)
/Connectors/PA26: U12.62 (PA26)
/Connectors/PA27: U12.70 (PA27)
/Connectors/PA28: U12.112 (PA28)
/Connectors/PA29: U12.129 (PA29)
/Connectors/PA30: U12.116 (PA30)
/Connectors/PA31: U12.118 (PA31)
/Connectors/PB0: U12.21 (PB0/AFE0_AD10)
/Connectors/PB1: U12.20 (PB1/AFE1_AD0)
/Connectors/PB2: U12.26 (PB2/AFE0_AD5)
/Connectors/PB3: U12.31 (PB3/AFE0_AD2)
/Connectors/PB4: U12.105 (PB4/TDI)
/Connectors/PB5: U12.109 (PB5/TDO)
/Connectors/PB6: U12.79 (PB6/SWDIO/TMS)
/Connectors/PB7: U12.89 (PB7/SWCLK/TCK)
/Connectors/PB12: TP2.1, U12.87 (PB12/ERASE)
/Connectors/PB13: U12.144 (PB13/DAC0)
/Connectors/PC0: U12.11 (PC0/AFE1_AD9)
/Connectors/PC1: U12.38 (PC1)
/Connectors/PC2: U12.39 (PC2)
/Connectors/PC3: U12.40 (PC3)
/Connectors/PC4: U12.41 (PC4)
/Connectors/PC5: U12.58 (PC5)
/Connectors/PC6: U12.54 (PC6)
/Connectors/PC7: U12.48 (PC7)
/Connectors/PC8: U12.82 (PC8)
/Connectors/PC9: U12.86 (PC9)
/Connectors/PC10: U12.90 (PC10)
/Connectors/PC11: U12.94 (PC11)
/Connectors/PC12: U12.17 (PC12/ADE1_AD3)
/Connectors/PC13: U12.19 (PC13/AFE1_AD1)
/Connectors/PC14: U12.97 (PC14)
/Connectors/PC15: U12.18 (PC15/AFE1_AD2)
/Connectors/PC16: U12.100 (PC16)
/Connectors/PC17: U12.103 (PC17)
/Connectors/PC18: U12.111 (PC18)
/Connectors/PC19: U12.117 (PC19)
/Connectors/PC20: U12.120 (PC20)
/Connectors/PC21: U12.122 (PC21)
/Connectors/PC22: U12.124 (PC22)
/Connectors/PC23: U12.127 (PC23)
/Connectors/PC24: U12.130 (PC24)
/Connectors/PC25: U12.133 (PC25)
/Connectors/PC26: U12.13 (PC26/AFE1_AD7)
/Connectors/PC27: U12.12 (PC27/AFE1_AD8)
/Connectors/PC28: U12.76 (PC28)
/Connectors/PC29: U12.16 (PC29/AFE1_AD4)
/Connectors/PC30: U12.15 (PC30/AFE1_AD5)
/Connectors/PC31: U12.14 (PC31/AFE1_AD6)
/Connectors/PD0: U12.1 (PD0/DAC1)
/Connectors/PD1: U12.132 (PD1)
/Connectors/PD2: U12.131 (PD2)
/Connectors/PD3: U12.128 (PD3)
/Connectors/PD4: U12.126 (PD4)
/Connectors/PD5: U12.125 (PD5)
/Connectors/PD6: U12.121 (PD6)
/Connectors/PD7: U12.119 (PD7)
/Connectors/PD8: U12.113 (PD8)
/Connectors/PD9: U12.110 (PD9)
/Connectors/PD10: U12.101 (PD10)
/Connectors/PD11: U12.98 (PD11)
/Connectors/PD15: U12.106 (PD15)
/Connectors/PD16: U12.78 (PD16)
/Connectors/PD17: U12.74 (PD17)
/Connectors/PD24: U12.55 (PD24)
/Connectors/PD25: U12.52 (PD25)
/Connectors/PD26: U12.53 (PD26)
/Connectors/PD27: U12.47 (PD27)
/Connectors/PD28: U12.71 (PD28/WKUP5)
/Connectors/PD31: U12.2 (PD31)
/Connectors/PE0: U12.4 (PE0/AFE1_AD11)
/Connectors/PE1: U12.6 (PE1)
/Connectors/PE2: U12.7 (PE2)
/Connectors/PE3: U12.10 (PE3/AFE1_AD10)
/Connectors/PE4: U12.27 (PE4/AFE0_AD4)
/Connectors/PE5: U12.28 (PE5/AFE0AD3)
/Connectors/USBD_N: U12.136 (HSDM); also elsewhere on the board
/Connectors/USBD_P: U12.137 (HSDP); also elsewhere on the board
/GNC_Processor/GPS-~RESET: U12.57 (PD23); also elsewhere on the board
/GNC_Processor/IMU-INT: U12.93 (PA2/WKUP2); also elsewhere on the board
/GNC_Processor/IMU-SPI-CLK: U12.60 (PD22); also elsewhere on the board
/GNC_Processor/IMU-SPI-MISO: U12.65 (PD20); also elsewhere on the board
/GNC_Processor/IMU-SPI-MOSI: U12.63 (PD21); also elsewhere on the board
/GNC_Processor/IMU-SPI-~CS: U12.92 (PD12); also elsewhere on the board
/GNC_Processor/VBATT: C90.1, R37.1, R38.2, U12.34 (PD30/AFE0_AD0)
/GNC_Processor/VBUS_DETECT: R21.2, R22.2, U12.108 (PD29)
/GNC_Processor/VDDPLLUSB: C86.2, L21.1, U12.143 (VDDPLLUSB)
/GNC_Processor/~RESET: C59.1, U12.83 (~RST); also elsewhere on the board
/GPS/GPS-Rx: U12.114 (PA6); also elsewhere on the board
/GPS/GPS-Tx: U12.73 (PA5/PIODC2); also elsewhere on the board
GND: C57.2, C59.2, C60.1, C61.2, C62.1, C63.1, C64.1, C65.1, C68.2, C69.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.1, C85.1, C86.1, C87.2, C90.2, R20.1, R21.1, R38.1, U12.8 (VREFN), U12.44 (GND), U12.61 (GND), U12.95 (GND), U12.115 (GND), U12.135 (GND), U12.138 (GND); also elsewhere on the board
unnamed: C57.1, C68.1, C69.1, C73.1, C75.1, C76.1, C77.1, L19.1, L20.1, U12.3 (VDDOUT), U12.29 (VDDCORE), U12.33 (VDDCORE), U12.50 (VDDCORE), U12.81 (VDDCORE), U12.107 (VDDCORE)
unnamed: C60.2, R20.2, U12.140 (VBG)
unnamed: C62.2, U12.35 (PA7/XIN32), Y1.1
unnamed: C63.2, U12.36 (PA8/XOUT32), Y1.2
unnamed: C64.2, U12.141 (PB8/XOUT), Y2.1
unnamed: C65.2, U12.142 (PB9/XIN), Y2.3
unnamed: C72.1, L20.2, U12.139 (VDDUTMIC)
unnamed: C74.1, L19.2, U12.123 (VDDPLL)
unnamed: L21.2, R23.2
unnamed: TP1.1, U12.85 (TST)
unnamed: TP3.1, U12.104 (JTAGSEL)
VUSB: C61.1, R22.1; also elsewhere on the board

Notes on the sheet:
Pin 5
Place one near each VDDIO pin
Place one near each VDDCORE pin

Parts:
C1, C2, C20, C24, C27, C29: 0.1u; C_0402; Voltage 16V; Tolerance 20%
C3, C19, C30: EMK212BBJ226MG-T; C_0805; Voltage 16V; Tolerance 20%
C4, C28: 1u; C_0402; Voltage 16V; Tolerance 20%
C5: GJM1555C1H3R3CB01D; C_0402; Voltage 16V; Tolerance 20%
C6: GJM1555C1H7R5CB01D; C_0402; Voltage 16V; Tolerance 20%
C7: DNP; C_0402; Voltage 16V; Tolerance 20%
C9, C13, C21: GRM1555C1H470FA01D; C_0402; Voltage 16V; Tolerance 20%
C14: CL05C2R2BB5NNNC; C_0402; Voltage 16V; Tolerance 20%
C15, C17, C18, C26, C66, C67: GRM1555C1H120GA01D; C_0402; Voltage 16V; Tolerance 20%
C16: EMK107BJ225KA-T; C_0603; Voltage 16V; Tolerance 20%
C25, C88: 0.01u; C_0402; Voltage 16V; Tolerance 20%
D6: MF-LED-0603-RED; LED_0603
FL1: SF2098H; SM2016-4
J4: 0734120110; Molex_Microcoaxial_RF
L1, L14: CIH10T22NJNC; L_0603
L2: LQG15HS7N5J02D; L_0402
L3, L13: HK10052N2S-T; L_0402
L4, L12, L18: LQG15HN9N1J02D; L_0402
L8: BRL1608T6R8M; L_0603
L15: BLM18HE152SN1D; L_0603
MP1: BMI-S-201-F; Laird_Technologies_BMI-S-201-F_13.66x12.70mm
R1, R2, R3: 10k; R_0402; Tolerance 1%; Voltage 16V
R4: RC0402FR-073K3L; R_0402; Tolerance 1%; Voltage 16V
R9: 47; R_0402; Tolerance 1%; Voltage 16V
R35: 100k; R_0402; Tolerance 1%; Voltage 16V
R47: 1k; R_0402; Tolerance 1%; Voltage 16V
U1: CC1310F128RGZR; QFN-48-1EP_7x7mm_Pitch0.5mm
U2: CC1190RGVR; QFN-16-1EP_4x4mm_Pitch0.65mm
Y3: XRCGB24M000F2P00R0; Crystal_SMD_2016-4pin_2.0x1.6mm

Connections:
+3V3: L15.1, R35.2, R47.1; also elsewhere on the board
/2.4_RESET_900: U1.9 (DIO_4); also elsewhere on the board
/900-TCKC: U1.25 (JTAG_TCKC)
/900-TMSC: U1.24 (JTAG_TMSC)
/900M-Rx: U1.7 (DIO_2); also elsewhere on the board
/900M-Tx: U1.8 (DIO_3); also elsewhere on the board
/900MHz Radio/HGM: R1.2, U1.10 (DIO_5)
/900MHz Radio/LNA_EN: R2.2, U1.12 (DIO_7)
/900MHz Radio/PA_EN: R3.2, U1.11 (DIO_6)
/900MHz Radio/RF50_900_1: C9.1, U1.1 (RF_P)
/900MHz Radio/RF50_900_2: C9.2, FL1.1 (IN)
/900MHz Radio/RF50_900_3: C14.2, FL1.3 (OUT), L12.1
/900MHz Radio/RF50_900_4: L12.2, U2.10 (LNA_OUT), U2.11 (PA_IN)
/900MHz Radio/RF50_900_5: C5.1, C21.2, L2.2, L3.1
/900MHz Radio/RF50_900_6: C6.1, L3.2, L4.1
/900MHz Radio/RF50_900_7: C26.2, L2.1
/900MHz Radio/RF50_900_ANT: C7.1, J4.1 (In), L4.2
/900MHz Radio/RF50_900_LNA: C18.2, U2.5 (LNA_IN)
/900MHz Radio/RF50_900_PA: C21.1, L1.1, U2.2 (PA_OUT)
/900MHz Radio/RF50_900_TR: C18.1, C26.1, U2.4 (TR_SW)
/900MHz Radio/VDDR_CC1310: C1.1, C2.1, C3.1, L8.2, U1.45 (VDDR), U1.48 (VDDR_RF)
/900MHz Radio/VDDS_CC1310: C16.1, C20.1, C24.1, C27.1, C29.1, C30.1, L14.1, L15.2, U1.13 (VDDS2), U1.22 (VDDS3), U1.34 (VDDS_DCDC), U1.44 (VDDS)
/900MHz Radio/VDD_CC1190: C13.1, C17.2, C19.1, C25.1, C28.1, L1.2, L13.2, L14.2, L18.2, R9.2
/900MHz Radio/~RESET: C88.1, R35.1, U1.35 (~RESET); also elsewhere on the board
/CPU-SCK: U1.15 (DIO_9); also elsewhere on the board
/CPU-SDA: U1.14 (DIO_8); also elsewhere on the board
/CPU_RESET_900: U1.6 (DIO_1); also elsewhere on the board
/Connectors/900-ADIO-23: U1.36 (DIO_23)
/Connectors/900-ADIO-24: U1.37 (DIO_24)
/Connectors/900-ADIO-25: U1.38 (DIO_25)
/Connectors/900-ADIO-26: U1.39 (DIO_26)
/Connectors/900-ADIO-27: U1.40 (DIO_27)
/Connectors/900-ADIO-28: U1.41 (DIO_28)
/Connectors/900-ADIO-29: U1.42 (DIO_29)
/Connectors/900-ADIO-30: U1.43 (DIO_30)
/Connectors/900-DIO-10: U1.16 (DIO_10)
/Connectors/900-DIO-11: U1.17 (DIO_11)
/Connectors/900-DIO-12: U1.18 (DIO_12)
/Connectors/900-DIO-13: U1.19 (DIO_13)
/Connectors/900-DIO-14: U1.20 (DIO_14)
/Connectors/900-DIO-15: U1.21 (DIO_15)
/Connectors/900-DIO-16: U1.26 (DIO_16)
/Connectors/900-DIO-17: U1.27 (DIO_17)
/Connectors/900-DIO-18: U1.28 (DIO_18)
/Connectors/900-DIO-19: U1.29 (DIO_19)
/Connectors/900-DIO-20: D6.1 (K), U1.30 (DIO_20)
/Connectors/900-DIO-21: U1.31 (DIO_21)
/Connectors/900-DIO-22: U1.32 (DIO_22)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C13.2, C14.1, C15.1, C16.2, C17.1, C19.2, C20.2, C24.2, C25.2, C27.2, C28.2, C29.2, C30.2, C66.1, C67.1, C88.2, FL1.2 (GND), FL1.4 (GND), J4.2 (Ext), MP1.1, R4.1, U1.49 (GND_EP), U2.1 (GND), U2.3 (GND), U2.9 (GND), U2.12 (GND), U2.17 (GND); also elsewhere on the board
unnamed: C4.1, U1.23 (DCOUPL)
unnamed: C15.2, L13.1, U2.13 (VDD_LNA)
unnamed: C66.2, U1.47 (X24M_P), Y3.1
unnamed: C67.2, U1.46 (X24M_N), Y3.3
unnamed: D6.2 (A), R47.2
unnamed: L8.1, U1.33 (DCDC_SW)
unnamed: L18.1, U2.16 (VDD_PA1)
unnamed: R1.1, U2.6 (HGM)
unnamed: R2.1, U2.7 (LNA_EN)
unnamed: R3.1, U2.8 (PA_EN)
unnamed: R4.2, U2.14 (BIAS)
unnamed: R9.1, U2.15 (VDD_PA2)

Notes on the sheet:
Shielded Area
PIN 13
PIN 22
PIN 44
PIN 34
PIN 45
PIN 48

Parts:
C8, C10, C12: CL05C2R2BB5NNNC; C_0402; Voltage 16V; Tolerance 20%
C11: DNP; C_0402; Voltage 16V; Tolerance 20%
C31, C32, C36, C40, C41, C42, C43: 0.1u; C_0402; Voltage 16V; Tolerance 20%
C33, C44: EMK212BBJ226MG-T; C_0805; Voltage 16V; Tolerance 20%
C34, C35: 1u; C_0402; Voltage 16V; Tolerance 20%
C37: 1n; C_0402; Voltage 16V; Tolerance 20%
C38, C39: EMK107BJ225KA-T; C_0603; Voltage 16V; Tolerance 20%
C70, C71: GRM1555C1H120GA01D; C_0402; Voltage 16V; Tolerance 20%
C89: 0.01u; C_0402; Voltage 16V; Tolerance 20%
D5: MF-LED-0603-GREEN; LED_0603
J5: 0734120110; Molex_Microcoaxial_RF
L5: HK10054N7S-T; L_0402
L6: LQG15HS1N0S02D; L_0402
L7: LQG15HS2N0S02D; L_0402
L9: MLZ1608N100LT000; L_0603
L10, L11: BLM18HE152SN1D; L_0603
MP2: BMI-S-201-F; Laird_Technologies_BMI-S-201-F_13.66x12.70mm
R5, R6, R7: 10k; R_0402; Tolerance 1%; Voltage 16V
R8: RC0402FR-073K9L; R_0402; Tolerance 1%; Voltage 16V
R36: 100k; R_0402; Tolerance 1%; Voltage 16V
R46: 1k; R_0402; Tolerance 1%; Voltage 16V
U3: CC2650F128RGZR; QFN-48-1EP_7x7mm_Pitch0.5mm
U4: CC2592RGVR; QFN-16-1EP_4x4mm_Pitch0.65mm
Y5: XRCGB24M000F2P00R0; Crystal_SMD_2016-4pin_2.0x1.6mm

Connections:
+3V3: L10.2, L11.2, R36.2, R46.1; also elsewhere on the board
/2.4 GHz Radio/HGM: R5.2, U3.9 (DIO_4)
/2.4 GHz Radio/LNA_EN: R6.2, U3.5 (DIO_0)
/2.4 GHz Radio/PA_EN: R7.2, U3.6 (DIO_1)
/2.4 GHz Radio/RF50_2.4_1: C8.1, L5.2, L6.1, U4.10 (ANT)
/2.4 GHz Radio/RF50_2.4_2: C10.1, L6.2, L7.1
/2.4 GHz Radio/RF50_2.4_3: C11.1, C12.2, L7.2
/2.4 GHz Radio/RF50_2.4_ANT: C12.1, J5.1 (In)
/2.4 GHz Radio/RF50_2.4_N: U3.2 (RF_N), U4.2 (RF_N)
/2.4 GHz Radio/RF50_2.4_P: U3.1 (RF_P), U4.3 (RF_P)
/2.4 GHz Radio/VDDR_CC2650: C31.1, C32.1, C33.1, L9.1, U3.45 (VDDR), U3.48 (VDDR_RF)
/2.4 GHz Radio/VDDS_CC2650: C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, L11.1, U3.13 (VDDS2), U3.22 (VDDS3), U3.34 (VDDS_DCDC), U3.44 (VDDS)
/2.4 GHz Radio/VDD_CC2592: C35.1, C36.1, C37.1, C38.1, L5.1, L10.1, U4.13 (VDD_LNA), U4.14 (VDD_BIAS), U4.15 (VDD_PA)
/2.4 GHz Radio/~RESET: C89.1, R36.1, U3.35 (~RESET); also elsewhere on the board
/2.4-TCKC: U3.25 (JTAG_TCKC)
/2.4-TMSC: U3.24 (JTAG_TMSC)
/2.4G-Rx: U3.7 (DIO_2); also elsewhere on the board
/2.4G-Tx: U3.8 (DIO_3); also elsewhere on the board
/900_RESET_2.4: U3.32 (DIO_22); also elsewhere on the board
/CPU-SCK: U3.11 (DIO_6); also elsewhere on the board
/CPU-SDA: U3.10 (DIO_5); also elsewhere on the board
/CPU_RESET_2.4: U3.31 (DIO_21); also elsewhere on the board
/Connectors/2.4-ADIO-23: U3.36 (DIO_23)
/Connectors/2.4-ADIO-24: U3.37 (DIO_24)
/Connectors/2.4-ADIO-25: U3.38 (DIO_25)
/Connectors/2.4-ADIO-26: U3.39 (DIO_26)
/Connectors/2.4-ADIO-27: U3.40 (DIO_27)
/Connectors/2.4-ADIO-28: U3.41 (DIO_28)
/Connectors/2.4-ADIO-29: U3.42 (DIO_29)
/Connectors/2.4-ADIO-30: U3.43 (DIO_30)
/Connectors/2.4-DIO-7: U3.12 (DIO_7)
/Connectors/2.4-DIO-8: U3.14 (DIO_8)
/Connectors/2.4-DIO-9: U3.15 (DIO_9)
/Connectors/2.4-DIO-10: U3.16 (DIO_10)
/Connectors/2.4-DIO-11: U3.17 (DIO_11)
/Connectors/2.4-DIO-12: U3.18 (DIO_12)
/Connectors/2.4-DIO-13: U3.19 (DIO_13)
/Connectors/2.4-DIO-14: U3.20 (DIO_14)
/Connectors/2.4-DIO-15: U3.21 (DIO_15)
/Connectors/2.4-DIO-16: U3.26 (DIO_16)
/Connectors/2.4-DIO-17: U3.27 (DIO_17)
/Connectors/2.4-DIO-18: U3.28 (DIO_18)
/Connectors/2.4-DIO-19: U3.29 (DIO_19)
/Connectors/2.4-DIO-20: D5.1 (K), U3.30 (DIO_20)
GND: C8.2, C10.2, C11.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C70.1, C71.1, C89.2, J5.2 (Ext), MP2.1, R8.1, U3.49 (GND_EP), U4.1 (GND), U4.4 (GND), U4.9 (GND), U4.11 (GND), U4.12 (GND), U4.16 (GND), U4.17 (GND); also elsewhere on the board
unnamed: C34.1, U3.23 (DCOUPL)
unnamed: C70.2, U3.47 (X24M_P), Y5.1
unnamed: C71.2, U3.46 (X24M_N), Y5.3
unnamed: D5.2 (A), R46.2
unnamed: L9.2, U3.33 (DCDC_SW)
unnamed: R5.1, U4.7 (HGM)
unnamed: R6.1, U4.6 (LNA_EN)
unnamed: R7.1, U4.5 (PA_EN)
unnamed: R8.2, U4.8 (BIAS)

Notes on the sheet:
RF Shield
CC2592 Decoupling
LNA Bias Filtering
Antenna Match
DC Block
Power Filtering.
CC2650 VDDS Decoupling
Pin 13
Pin 22
Pin 44
Pin 34
Pin 45
Pin 48
VDDR Decoupling
Using BLE without RTC Crystal requires calibration over temp: http://www.ti.com/lit/an/swra499a/swra499a.pdf

Parts:
C22: 0.1u; C_0402; Voltage 16V; Tolerance 20%
C23, C53: 0.01u; C_0402; Voltage 16V; Tolerance 20%
J6: 0734120110; Molex_Microcoaxial_RF
R14: ERJ-14YJ100U; R_1210; Tolerance 1%; Voltage 16V
U9: MAX-M8W-0; U-BLOX-MAX

Connections:
+3V3: C22.1, C23.1, U9.6 (V_BCKP), U9.7 (VCC_IO), U9.8 (VCC); also elsewhere on the board
/CPU-SCK: U9.17 (SCL); also elsewhere on the board
/CPU-SDA: U9.16 (SDA); also elsewhere on the board
/GNC_Processor/GPS-~RESET: U9.9 (~RESET); also elsewhere on the board
/GPS/GPS-Rx: U9.3 (RXD); also elsewhere on the board
/GPS/GPS-Tx: U9.2 (TXD); also elsewhere on the board
/GPS/RF_GPS_ANT: J6.1 (In), U9.11 (RF_IN)
GND: C22.2, C23.2, C53.2, J6.2 (Ext), U9.1 (GND), U9.10 (GND), U9.12 (GND); also elsewhere on the board
unnamed: C53.1, R14.1, U9.14 (VCC_RF)
unnamed: R14.2, U9.15 (V_ANT)

Notes on the sheet:
10 ohm bias
