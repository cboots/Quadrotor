# Repository cboots/Quadrotor (continued)

## KiCad design Avionics/Flight Computer/Flight Computer.kicad_pcb (continued)

Parts:
C45: 0.01u; C_0402; Voltage 16V; Tolerance 20%
C46, C95: GRM1555C1H120GA01D; C_0402; Voltage 16V; Tolerance 20%
C47: 0.1u; C_0402; Voltage 16V; Tolerance 20%
C48, C49, C96: GRM31CR61H106MA12L; C_1206; Voltage 50V; Tolerance 20%
C50: UMK212BB7225KG-T; C_0805; Voltage 50V; Tolerance 20%
C51, C52: EMK212BBJ226MG-T; C_0805; Voltage 16V; Tolerance 20%
D1, D2, D7: SS24FL; D_SOD-123F
L16, L17: 74404052100; Inductor_Wurth_LQS-5020
R10, R11: 18k; R_0402; Tolerance 1%; Voltage 16V
R12: ERJ-2RKF5761X; R_0402; Tolerance 1%; Voltage 16V
U8: TPS54232; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+3V3: C51.1, C52.1, L17.2, R11.1; also elsewhere on the board
+BATT: D2.2 (A); also elsewhere on the board
/Power-~SHDN~: U8.3
GND: C45.2, C46.1, C48.2, C49.2, C50.2, C51.2, C52.2, C95.1, C96.2, D7.2 (A), R12.2, U8.7; also elsewhere on the board
unnamed: C45.1, R10.2
unnamed: C46.2, R10.1, U8.6
unnamed: C47.1, D7.1 (K), L17.1, U8.8
unnamed: C47.2, U8.1
unnamed: C48.1, D1.1 (K), D2.1 (K), L16.1
unnamed: C49.1, C50.1, C96.1, L16.2, U8.2
unnamed: C95.2, U8.4
unnamed: R11.2, R12.1, U8.5
VUSB: D1.2 (A); also elsewhere on the board

Notes on the sheet:
Input pi filter (helps block ESC noise)
@1A
3.5 to 36V input (derates for 28.8V)
12pF
5.76k
10uH

Parts:
C54: 0.01u; C_0402; Voltage 16V; Tolerance 20%
C55, C56, C58: 0.1u; C_0402; Voltage 16V; Tolerance 20%
R15: 47; R_0402; Tolerance 1%; Voltage 16V
R16, R17, R18, R19: 1k; R_0402; Tolerance 1%; Voltage 16V
R42: 10k; R_0402; Tolerance 1%; Voltage 16V
U5: MPU-9250; QFN-24-1EP_3x3mm_Pitch0.4mm_MPU-9250
U7: LPS25HBTR; HLGA-10L_2.5x2.5mm_Pitch0.6mm

Connections:
+3V3: C54.1, R15.1, R16.1, R17.1, R18.1, R19.1, R42.1, U5.1 (RESV_VDDIO), U5.8 (VDDIO); also elsewhere on the board
/Connectors/AUX_SCL: R18.2, U5.7 (AUX_SCL), U7.2 (SCL/SPC)
/Connectors/AUX_SDA: R17.2, U5.6 (AUX_SDA), U7.4 (SDA/SDI/SDO)
/GNC_Processor/IMU-INT: U5.12 (INT); also elsewhere on the board
/GNC_Processor/IMU-SPI-CLK: U5.23 (SCL/SCLK); also elsewhere on the board
/GNC_Processor/IMU-SPI-MISO: U5.9 (AD0/MISO); also elsewhere on the board
/GNC_Processor/IMU-SPI-MOSI: U5.24 (SDA/MOSI); also elsewhere on the board
/GNC_Processor/IMU-SPI-~CS: R42.2, U5.22 (~CS); also elsewhere on the board
GND: C54.2, C55.2, C56.2, C58.2, U5.11 (FSYNC), U5.18 (GND), U5.20 (RESV_GND), U7.3 (Reserved), U7.8 (GND), U7.9 (GND); also elsewhere on the board
unnamed: C55.1, R15.2, U5.13 (VDD)
unnamed: C56.1, U5.10 (REGOUT)
unnamed: C58.1, R19.2, U7.1 (VDD_IO), U7.10 (VDD)
unnamed: R16.2, U7.5 (SDO/SA0), U7.6 (~CS)

Notes on the sheet:
Input filter to reduce sensor reference noise. 1.5kHz cutoff, 25uA bias current worst case
Pull CS up for I2C operation Address 1011101b (SA0 high)
High Precision Barometer
9-DOF IMU, gyro/accel/mag
Input filter to reduce sensor reference noise. 33kHz cutoff, 3.5mA bias current worst case
Frame Sync Unused
Register map and descriptions: https://cdn.sparkfun.com/assets/learn_tutorials/5/5/0/MPU-9250-Register-Map.pdf
AUX bus goes to connector for expansion sensors
Layout Note: Exposed pad is NC. Do not solder the exposed pad.

Schematic: Connectors.sch

Parts:
J1, J2: AXK5S80047YG
J3: 473460001; USB_Micro-B_0473460001
U13: NUF2042XV6; SOT-563

Connections:
/Connectors/USBD_N: U13.6; also elsewhere on the board
/Connectors/USBD_P: U13.4; also elsewhere on the board
GND: J3.5 (GND), J3.6 (Shield), U13.2; also elsewhere on the board
unnamed: J3.2 (D-), U13.1
unnamed: J3.3 (D+), U13.3
VUSB: J3.1 (VBUS), U13.5; also elsewhere on the board

Notes on the sheet:
Mating connector AXK6S80447YG
Must be connected to open drain

Board: 4 copper layers, 50.0 x 40.0 mm, 203 parts (51 on the bottom side), 126 nets.

Other parts of the board:
MK3, MK4: Mounting_Hole; MountingHole_2.5mm

## Commit log

2013-06-15 Added directory structure and start of airframe assembly.
2013-06-15 Added more detail to the assembly. Now contains estimates of body, booms, motor mounts, and landing struts.
2013-06-15 Committed updated parts lib
2013-06-15 Commited directory structure.
2013-06-15 Added placeholder ESC's to the assembly.
    Committed System Block Diagram
2013-06-16 Added zipties to ESC Detailed notes on drawing
2013-06-16 Added chart of naming conventions for quadrotor body frame.
2013-06-17 Added start of Power Distribution board
2013-06-19 Added current sense circuits and most of the switching regulator.
    Need to add signal splitters and output pins.
2013-06-21 Finished switcher circuit, almost there.
2013-06-26 Completed layout and routing. Adding vias later
2013-06-26 Cleaned up silk
2013-06-26 Added more silk and changed vias to tented small circles
2013-06-27 Committed file outputs and cleaned silk. Added shock hazard symbol
2013-06-27 Committed final version of power distribution board and added to sketchup assembly.
2013-06-30 Added Cortex M3 chip to library
    Started schematic for flight computer.
2013-07-03 Added LPC4337 to library. Damn that took a long time
2013-07-14 Broke out all of the flight computer MCU ports and assigned the dedicated signals for use internally.
2013-07-14 Pin Assignments for FC MCU
2013-07-14 Added PPM encoder framework from Ardupilot mega schematic
2013-07-18 Added IMU. Needs some work
2013-07-19 Exported all parts to libraries. Replaced IMU with MPU-6000.
2013-07-21 Connected sensor network and added pressure sensor
2013-07-21 Added 16MB flash chip for core event logging and mission profile configuration. Internal EEPROM will be used for core configuration (failsafe modes, dead zones, etc), external flash will store missio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
2013-07-21 Added Micro SD Card slot
2013-07-23 Added several connectors and modified power inputs to not immediately go to 5V plane.
2013-07-23 Replaced all parts with 0402 packages to save board space.
    I'm gonna need a smaller tweezers...
2013-07-24 Added power management circuitry
2013-07-26 Changed form factor of FC to be 1.95"x1.95" to be compliant with the power distribution board. Makes stacking and interconnectivity simpler.
2013-07-27 Consolidated entire design into single FC library. Makes everything neater and avoids package conflicts. Using any new package should be added to this library OR copied to it from another lib.
2013-07-27 Finished first attempt to layout EVERYTHING.
2013-07-27 Added EagleUP model libraries plus a few custom ones. Will be adding more models just to be cool.
2013-07-27 Migrated models to separate repo https://github.com/cboots/EagleUpModels.git
2013-07-27 Refactored power distrib board libraries into single library
2013-07-28 Updated board for model compatibility (no actual layout or part changes).
2013-07-28 Updated airframe with full 3D power board.
2013-07-28 Minor updates.
2013-07-28 Updated part references.
2013-07-28 Updated part references
2013-07-28 Updated Power Distribution Board with new detailed connector models
2013-07-29 Updated airframe with preliminary flight computer design.
2013-07-31 Added early sketch of pcb quad design to facilitate long term planning.
2013-07-31 Minor updates to PCB
2013-08-01 Added some connectors
2013-08-01 Saved positioning
2013-08-01 Updated PCBA model
2013-08-02 Finished pinout for shield headers
2013-08-02 Some progress on routing
2013-08-04 Lots more routing done
2013-08-04 More routing
2013-08-04 Only 4 wires left. Sooo close
2013-08-04 Finished routing and updated ariframe assembly
2013-08-04 Adjusted FC size to align with power board.
2013-08-04 Tracked down the last few airwires
2013-08-04 Cleaned up silkscreen and added part numbers.
2013-08-04 Added power on LED.
2013-08-04 Deleting extra backups
2013-08-06 Cleaned up silk, added missed layers, exported paste layers.
2013-08-07 Added sketch of sharp rangefinder sensor placement. Probably will not stay in this configuration, may not be tall enough to get over props. Also don't want the stack getting too tall or heavy. All sh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
2013-08-08 Changed model to X configuration. Software will eventually be able to handle both, but start with X.
    Added naming conventions for cross config
2013-08-11 Added a couple voltage dividers to make level shifts safer.
2013-08-29 Continuing to rework flight computer board.
2015-05-13 Added XMC4500-F100K1024 AB.lbr
2015-05-13 Started to revamp design.
2015-05-13 Fresh start. FU eagle.
2015-05-14 Added avionics library as Eagle-Library submodule.
2015-05-14 Added IMU to library
2015-05-15 Removed software directory
2015-05-15 Added barometer
2015-05-16 Added memory module
2015-05-17 Added radio part
2015-05-17 Updated git ignore
2015-05-25 Added radio components
2015-06-01 Added RF base station project
2015-06-05 Fixed library references and added balun to 2.4GHz circuit
2015-06-06 Applied DRU
2015-06-07 Added more updates to board layout.
2015-06-08 Finished first draft of 2.4GHz layout.
2015-06-09 Started to build 900MHz circuit
2017-02-16 Restarted as KiCad Project. KiCad is cool now.
2017-02-20 Added framework and started capturing radio schematics.
2017-02-20 Added more RF passives and placement of RF front ends
2017-02-21 Lots of power tree and layout work
2017-02-26 Restarted initial layout and cleaned up decoupling/RF layout.
2017-02-28 Nearly completed initial placement.
2017-03-03 Added additional pinout
2017-03-03 Wired up everything and started rearranging layout
2017-03-03 Finished breaking out signals to connector sheet and interconnecting processors.
2017-03-03 Fixed missing connections and did more layout
2017-03-03 Swapped some pins to make routing easier.
2017-03-04 Some more pin swapping and routing of signals. Placed reset pullup resistors.
2017-03-04 Cleaned up vias and DRC Errors
2017-03-04 Continuing to route out MCU signals.
2017-03-04 Did some more routing
2017-03-05 Additional routing
2017-03-05 Finished routing and DRC check.
2017-03-05 Cleaned up routing details and plane continuity problems.
2017-03-06 Fixed some grounding and routing. Moved USB input diode to top side to make reduced BOM easier.
2017-03-06 Silkscreen cleanup.
2017-03-06 Silkscreen and dimension drawing fixes
2017-03-07 Added LEDs
2017-03-07 Cleaned up silk and DRC for new components.
2017-03-08 Changed LED configuration, added smart driver chip to let all the CPUs access it..
2017-03-08 DFM/BOM Optimizations
2017-03-09 Added Logo, connected GPS SDA/SCL, and cleaned silk.
2017-03-09 Added option resistors for IMU to be connected to radio chips via I2C
2017-03-09 Added pullup to CS
2017-03-09 Fixed hopefully last DRC error.
2017-03-10 Built outputs and added manufacturing part numbers to make BOM search easier.
2017-03-10 Rebuilt output files and generated a few BOM fixes.
2017-03-10 Updated more manufacturing part numbers for macrofab compatibility.
2017-03-10 Fixed connector part number
2017-03-15 Finished rerouting and power supply update. Replaced connectors and did initial replacement.
2017-03-15 Reduced inductor size at small efficiency cost.
2017-03-16 Finished replacement and supply tuning
2017-03-16 Minor BOM fixes.
2017-03-16 Refactored repo into Navi repo
